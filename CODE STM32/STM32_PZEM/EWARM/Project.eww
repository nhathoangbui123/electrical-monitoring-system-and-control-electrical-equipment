<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32_PZEM.ewp</path>
  </project>
  <batchBuild />
</workspace>
